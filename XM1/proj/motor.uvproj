# Keil uVision project motor.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RD2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: motor +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user
  group Source Group 1
    ./: STARTUP.A51
    ./user/: mian.c adc.c motor.c angle.c
